# Keil uVision project ad5791-volt-source.uvprojx, settings and files
target AD5791Ref (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F070F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ad5791-ref +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F030,USE_STDPERIPH_DRIVER,M_PI=3.14159265358979f,__CLK_TCK=100,RT_USING_ULOG
  c misc: --preinclude ..\stm32f0xx_conf.h
  c include: ..\stm32f0xxlib\CMSIS\Device\ST\STM32F0xx\Include;..\stm32f0xxlib\CMSIS\Include;..\stm32f0xxlib\STM32F0xx_StdPeriph_Driver\inc;..\src;..\src\app;..\src\bsp;..\src\3rdparty\fifo;..\src\3rdparty\printf;..\src\3rdparty\ulog-noos;..\src\3rdparty\ush;..\src\3rdparty
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep *.o(ushtable)
  group USER
    ../src/: main.c stm32f0xx_it.c
  group APP
    ../src/app/: serial_frame.c voltref.c hmi.c ezled-host.c
  group LIB
    ../stm32f0xxlib/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../stm32f0xxlib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_wwdg.c stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
    ../src/: system_stm32f0xx.c
  group BSP
    ../src/bsp/: ad5791.c key.c uart.c timer.c adt7420.c i2c.c parameter.c
  group 3rdparty
    ../src/3rdparty/fifo/: fifo.c
    ../src/3rdparty/printf/: printf.c
    ../src/3rdparty/ulog-noos/: ulog.c
    ../src/3rdparty/ulog-noos/backend/: console_be.c
    ../src/3rdparty/ush/: ush.c
